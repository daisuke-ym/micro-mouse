# Repository daisuke-ym/micro-mouse

File README.md:

# マイクロマウスを作る

2026年度の取り組みは src2026 ブランチにあります。
以下の概要は2025年度の取り組みです。

## はじめに

マイクロマウスは自立型ロボットが自律的に（自分の力だけで）迷路を探索し、 ゴールまで到達するものです。

競技会もあります。
詳細は
[公益財団法人ニューテクノロジー振興財団](https://www.ntf.or.jp/mouse/) 
を参照してください。

## ここで作るマイクロマウス

上記競技会ではクラシッククラスとハーフサイズクラスがありますが、
ここでは1区画180㎜のクラシッククラスを作ります。

[RT ROBOT SHOP](https://www.rt-shop.jp/index.php?main_page=product_info&products_id=4229)
等でキットが販売されていますが、高価なため個人や学生が手を出すには敷居が高いです。

そこで、3Dプリンタ、我らの秋月電子通商、中国のプリント基板業者を駆使することで
1万円以内で製作できることを目指しました。

ただし、採用しているステッピングモーター（28BYJ-48）は回転速度が遅い[^1]ため、
上記競技会で完走するのは難しいです。
主に教材用と考えてもらえればと思います。

## 主要部品

| 構成部品 | 仕様等 |
|-|-|
| マイコン | [ESP32 DevKitC](https://akizukidenshi.com/catalog/g/g115673/) |
| モーター | [28BYJ-48](https://akizukidenshi.com/catalog/g/g113256/) |
| シャーシ | 専用設計プリント基板と兼用 |
| タイヤ   | 3Dプリント、TAMIYA 70144ボールキャスター |
| 電源     | 1.2V Ni-MH電池 または アルカリ乾電池 x4本 |
| 赤外線LED | [OSI5FU5111C-40](https://akizukidenshi.com/catalog/g/g103261/) |
| フォトトランジスタ | [L-51ROPT1D1](https://akizukidenshi.com/catalog/g/g104211/) |

## 開発環境

- Arduino IDE
- ESP32 ツールチェイン
- [Unistep2_mod](https://github.com/daisuke-ym/Unistep2_mod)
ライブラリ（動的に回転速度を変更できるようにしたもの）

[^1]: Unistep2 ライブラリを用いてほぼ最高速度で回しても約15rpmなので、
1区画進むのに約4秒かかります。
大会では16x16区画、256区画あるので、全探索するのに15分以上かかるため、
偶然を除いて競技時間10分以内に完走することは不可能です。

## KiCad design PCB/stepper-mouse-2026a/stepper-mouse-2026a.kicad_pcb

Parts:
C1, C2, C3, C4, C5, C6, C7: 1u; C_0603_1608Metric; LCSC C15849
D1: GREEN; LED_D5.0mm
D2: RED; LED_D5.0mm
D3, D4, D5, D6, D7, D8, D9, D10: SM4007PL; D_SOD-123F; LCSC C64898
D11, D12, D13, D14: OSI5FU5111C-40; LED_D5.0mm_Horizontal_O3.81mm_Z9.0mm
J1: STEPPER L; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
J2: STEPPER R; JST_XH_B5B-XH-A_1x05_P2.50mm_Vertical
J3: Power; PinHeader_1x02_P2.54mm_Vertical
LCD1: AQM1602Y
PH1, PH2, PH3, PH4: L-51ROPT1D1; LED_D5.0mm_Horizontal_O6.35mm_Z15.0mm
Q1, Q2: AO3401A; SOT-23; LCSC C15127
Q3, Q4, Q5, Q6, Q7, Q8, Q9, Q10: AO3400A; SOT-23; LCSC C20917
Q11, Q12, Q13, Q14: BSS138; SOT-23; LCSC C7420339
R1, R2, R23, R26, R29, R32: 1k; R_0603_1608Metric; LCSC C21190
R3, R4, R6, R8, R10, R12, R14, R16, R18, R20, R22, R25, R28, R31, R33, R34: 10k; R_0603_1608Metric; LCSC C25804
R5, R7, R9, R11, R13, R15, R17, R19, R21, R24, R27, R30: 10; R_0603_1608Metric; LCSC C22859
SW1: SW1; DTS-6-V-2
SW2: SW2; DTS-6-V-2
SW3: RESET; DTS-6-V-2
SW4: L_POWER; SS12D01G4
SW5: M_POWER; SS12D01G4
U1: ESP32-DevKitC
U2: AE-BNO055

Connections:
+3V3: C1.1, C2.1, LCD1.5 (3V3), PH1.1 (C), PH2.1 (C), PH3.1 (C), PH4.1 (C), R3.1, R4.1, R21.1, R24.1, R27.1, R30.1, U1.1 (3V3), U2.1 (VIN)
+5V: Q1.3 (D), U1.19 (5V)
+5VP: D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), J1.1, J2.1, Q2.3 (D)
/BT: J3.1, Q1.2 (S), Q2.2 (S), R33.1, R34.1
/IRLED_L_FR: Q12.1 (G), Q13.1 (G), R25.1, R28.1, U1.12 (G14/ADC2_6)
/IRLED_R_FL: Q11.1 (G), Q14.1 (G), R22.1, R31.1, U1.11 (G27/ADC2_7)
/LED1: D1.2 (A), U1.37 (G23/MOSI)
/LED2: D2.2 (A), U1.13 (G12/ADC2_5)
/RESET: LCD1.9 (~RESET), SW3.2, SW3.4, U1.2 (EN), U2.5 (~RESET)
/SCL: LCD1.8 (SCL), R4.2, U1.36 (G22/SCL), U2.4 (SCL)
/SDA: LCD1.7 (SDA), R3.2, U1.33 (G21/SDA), U2.3 (SDA)
/STP1P1: R5.2, U1.27 (G16)
/STP1P1X: D3.2 (A), J1.2, Q3.3 (D)
/STP1P2: R7.2, U1.28 (G17)
/STP1P2X: D4.2 (A), J1.3, Q4.3 (D)
/STP1P3: R9.2, U1.29 (G5/SS)
/STP1P3X: D5.2 (A), J1.4, Q5.3 (D)
/STP1P4: R11.2, U1.30 (G18/SCK)
/STP1P4X: D6.2 (A), J1.5, Q6.3 (D)
/STP2P1: R13.2, U1.7 (G32/ADC1_4)
/STP2P1X: D7.2 (A), J2.2, Q7.3 (D)
/STP2P2: R15.2, U1.8 (G33/ADC1_5)
/STP2P2X: D8.2 (A), J2.3, Q8.3 (D)
/STP2P3: R17.2, U1.9 (G25/ADC1_8)
/STP2P3X: D9.2 (A), J2.4, Q9.3 (D)
/STP2P4: R19.2, U1.10 (G26/ADC2_9)
/STP2P4X: D10.2 (A), J2.5, Q10.3 (D)
/SW1: SW1.2, SW1.4, U1.31 (G19/MISO)
/SW2: SW2.2, SW2.4, U1.15 (G13/ADC2_4)
/WS_FL: PH1.2 (E), R23.1, U1.6 (G35/ADC1_7)
/WS_FR: PH3.2 (E), R29.1, U1.3 (G36/ADC1_0)
/WS_L: PH2.2 (E), R26.1, U1.5 (G34/ADC1_6)
/WS_R: PH4.2 (E), R32.1, U1.4 (G39/ADC1_3)
GND: C2.2, C4.2, C5.2, C6.2, C7.2, J3.2, LCD1.6 (GND), Q3.2 (S), Q4.2 (S), Q5.2 (S), Q6.2 (S), Q7.2 (S), Q8.2 (S), Q9.2 (S), Q10.2 (S), Q11.2 (S), Q12.2 (S), Q13.2 (S), Q14.2 (S), R1.1, R2.2, R6.1, R8.1, R10.1, R12.1, R14.1, R16.1, R18.1, R20.1, R22.2, R23.2, R25.2, R26.2, R28.2, R29.2, R31.2, R32.2, SW1.1, SW1.3, SW2.1, SW2.3, SW3.1, SW3.3, SW4.2 (B), SW5.2 (B), U1.14 (GND), U1.32 (GND), U1.38 (GND), U2.2 (GND), U2.7 (GND)
unnamed: D1.1 (K), R1.2
unnamed: D2.1 (K), R2.1
unnamed: C4.1, D11.2 (A), R21.2
unnamed: D11.1 (K), Q11.3 (D)
unnamed: C5.1, D12.2 (A), R24.2
unnamed: D12.1 (K), Q12.3 (D)
unnamed: C6.1, D13.2 (A), R27.2
unnamed: D13.1 (K), Q13.3 (D)
unnamed: C7.1, D14.2 (A), R30.2
unnamed: D14.1 (K), Q14.3 (D)
unnamed: C3.1, LCD1.3 (CAP1N)
unnamed: C3.2, LCD1.4 (CAP1P)
unnamed: C1.2, LCD1.2 (VOUT)
unnamed: Q1.1 (G), R33.2, SW4.1 (A)
unnamed: Q2.1 (G), R34.2, SW5.1 (A)
unnamed: Q3.1 (G), R5.1, R6.2
unnamed: Q4.1 (G), R7.1, R8.2
unnamed: Q5.1 (G), R9.1, R10.2
unnamed: Q6.1 (G), R11.1, R12.2
unnamed: Q7.1 (G), R13.1, R14.2
unnamed: Q8.1 (G), R15.1, R16.2
unnamed: Q9.1 (G), R17.1, R18.2
unnamed: Q10.1 (G), R19.1, R20.2

Notes on the sheet:
モータ用電源スイッチ
195mA
スイッチ
OFF
JST SM
G0, G2はブートストラップに使用するので、 接続する機器に注意が必要。 G0はプルアップされているので、スイッチは問題ない。 G2はプルダウンされているので、特に注意が必要。 G12はフラッシュ書き込み時の電圧設定にかかわるので注意が必要。 LEDをつなぐ分には問題ない。
IMU，液晶ディスプレイ
ロジック用電源スイッチ
ステッピングモータ
壁センサ

Board: 2 copper layers, 85.0 x 114.0 mm, 85 parts (68 on the bottom side), 57 nets.

Other parts of the board:
TAMIYA70144: VAL**; TAMIYA70144

## KiCad design PCB/base-board/base-board.kicad_pcb

Parts:
D1: RED; LED_D5.0mm
D2: GREEN; LED_D5.0mm
J1: POWER; PinHeader_1x02_P2.54mm_Vertical
J2: ENCODER1; PinHeader_1x04_P2.54mm_Vertical
J3: ENCODER2; PinHeader_1x04_P2.54mm_Vertical
J4: SENSOR; PinHeader_1x08_P2.54mm_Vertical
J5: MOTOR1; PinHeader_1x02_P2.54mm_Vertical
J6: MOTOR2; PinHeader_1x02_P2.54mm_Vertical
LCD1: AE-AQM0802
R1, R2: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
SW1: SW1; DTS-6-V-2
SW2: SW2; DTS-6-V-2
SW3: RESET; DTS-6-V-2
U1: AE-TC78H653FTG; DIP-16_W7.62mm
U2: ESP32-DevKitC
U3: AE-BNO055-BO

Connections:
+3.3V: J2.1, J3.1, J4.1, LCD1.1 (VDD), U1.3 (STBY), U2.1 (3V3), U3.1 (VIN)
+BATT: J1.1, U1.15 (VM), U1.16 (VM), U2.19 (5V)
/ENC_1A: J2.2, U2.27 (G16)
/ENC_1B: J2.3, U2.26 (G4/ADC2_0)
/ENC_2A: J3.2, U2.12 (G14/ADC2_6)
/ENC_2B: J3.3, U2.13 (G12/ADC2_5)
/IRLED_L_FR: J4.4, U2.8 (G33/ADC1_5)
/IRLED_R_FL: J4.5, U2.7 (G32/ADC1_4)
/LED1: D1.2 (A), U2.11 (G27/ADC2_7)
/LED2: D2.2 (A), U2.10 (G26/ADC2_9)
/M1A: U1.7 (IN1), U2.31 (G19/MISO)
/M1B: U1.6 (IN2), U2.30 (G18/SCK)
/M2A: U1.5 (IN3), U2.29 (G5/SS)
/M2B: U1.4 (IN4), U2.28 (G17)
/RESET: LCD1.2 (~RESET), SW3.2, SW3.4, U2.2 (EN), U3.5 (~RESET)
/SCL: LCD1.3 (SCL), U2.36 (G22/SCL), U3.4 (SCL)
/SDA: LCD1.4 (SDA), U2.33 (G21/SDA), U3.3 (SDA)
/SENSOR_FL: J4.2, U2.3 (G36/ADC1_0)
/SENSOR_FR: J4.7, U2.6 (G35/ADC1_7)
/SENSOR_L: J4.3, U2.4 (G39/ADC1_3)
/SENSOR_R: J4.6, U2.5 (G34/ADC1_6)
/SW1: SW1.2, SW1.4, U2.37 (G23/MOSI)
/SW2: SW2.2, SW2.4, U2.9 (G25/ADC1_8)
GND: J1.2, J2.4, J3.4, J4.8, LCD1.5 (GND), R1.1, R2.1, SW1.1, SW1.3, SW2.1, SW2.3, SW3.1, SW3.3, U1.1 (LARGE), U1.2 (MODE), U1.8 (GND), U1.9 (GND), U1.10 (GND), U2.14 (GND), U2.32 (GND), U2.38 (GND), U3.2 (GND), U3.7 (GND)
unnamed: D1.1 (K), R1.2
unnamed: D2.1 (K), R2.2
unnamed: J5.1, U1.12 (OUT1)
unnamed: J5.2, U1.11 (OUT2)
unnamed: J6.1, U1.13 (OUT3)
unnamed: J6.2, U1.14 (OUT4)

Board: 2 copper layers, 70.0 x 90.0 mm, 17 parts (1 on the bottom side), 30 nets.

## KiCad design PCB/sensor-board/sensor-board.kicad_pcb

Parts:
C1, C2, C3, C4: 1u; C_0805_2012Metric
D1, D2, D3, D4: OSI5FU5111C-40; LED_D5.0mm_Horizontal_O3.81mm_Z9.0mm
J1: SENSOR; PinHeader_1x08_P2.54mm_Vertical
PH1, PH2, PH3, PH4: L-51ROPT1D1; LED_D5.0mm_Horizontal_O6.35mm_Z15.0mm
Q1, Q2, Q3, Q4: BSS138; SOT-23
R1, R4, R7, R10: 10; R_0603_1608Metric
R2, R5, R8, R11: 10k; R_0603_1608Metric
R3, R6, R9, R12: 1k; R_0603_1608Metric

Connections:
+3.3V: J1.1, PH1.1 (C), PH2.1 (C), PH3.1 (C), PH4.1 (C), R1.1, R4.1, R7.1, R10.1
/IRLED_L_FR: J1.4, Q2.1 (G), Q3.1 (G), R5.1, R8.1
/IRLED_R_FL: J1.5, Q1.1 (G), Q4.1 (G), R2.1, R11.1
/SENSOR_FL: J1.2, PH1.2 (E), R3.1
/SENSOR_FR: J1.7, PH3.2 (E), R9.1
/SENSOR_L: J1.3, PH2.2 (E), R6.1
/SENSOR_R: J1.6, PH4.2 (E), R12.1
GND: C1.2, C2.2, C3.2, C4.2, J1.8, Q1.2 (S), Q2.2 (S), Q3.2 (S), Q4.2 (S), R2.2, R3.2, R5.2, R6.2, R8.2, R9.2, R11.2, R12.2
unnamed: C1.1, D1.2 (A), R1.2
unnamed: D1.1 (K), Q1.3 (D)
unnamed: C2.1, D2.2 (A), R4.2
unnamed: D2.1 (K), Q2.3 (D)
unnamed: C3.1, D3.2 (A), R7.2
unnamed: D3.1 (K), Q3.3 (D)
unnamed: C4.1, D4.2 (A), R10.2
unnamed: D4.1 (K), Q4.3 (D)

Notes on the sheet:
195mA

Board: 2 copper layers, 70.0 x 58.0 mm, 34 parts (4 on the bottom side), 16 nets.

Other parts of the board:
CH**: CuttingHole_0.8
CH**#2, CH**#3, CH**#4, CH**#5: CuttingHole_0.8

## KiCad design PCB/rotary-encoder3/rotary-encoder3.kicad_pcb

Parts:
C1: 0.1u; C_0603_1608Metric
J1: ENC_OUT; PinHeader_1x06_P2.54mm_Horizontal
PH1, PH2, PH3, PH4: LBR-123F
R1, R2, R5, R6: 100; R_0603_1608Metric
R3, R4, R7, R8: 10k; R_0603_1608Metric
U1: 74HC14; TSSOP-14_4.4x5mm_P0.65mm

Connections:
+3.3V: C1.1, J1.1, R1.1, R2.1, R3.1, R4.1, R5.1, R6.1, R7.1, R8.1, U1.14 (VCC)
/1A_OUT: J1.2, U1.2
/1B_OUT: J1.3, U1.4
/2A_OUT: J1.4, U1.12
/2B_OUT: J1.5, U1.10
GND: C1.2, J1.6, PH1.2, PH1.3, PH2.2, PH2.3, PH3.2, PH3.3, PH4.2, PH4.3, U1.5, U1.7 (GND), U1.9
unnamed: PH1.1, R1.2
unnamed: PH1.4, R3.2, U1.1
unnamed: PH2.1, R2.2
unnamed: PH2.4, R4.2, U1.3
unnamed: PH3.1, R5.2
unnamed: PH3.4, R7.2, U1.13
unnamed: PH4.1, R6.2
unnamed: PH4.4, R8.2, U1.11

Board: 2 copper layers, 39.0 x 23.0 mm, 15 parts (1 on the bottom side), 14 nets.

## KiCad design PCB/rotary-encoder2/rotary-encoder2.kicad_pcb

Parts:
C1: 0.1u; C_0603_1608Metric
J1: OUT; PinHeader_1x04_P2.00mm_Vertical
PH1, PH2: LBR-123F
R1, R2: 100; R_0603_1608Metric
R3, R4: 10k; R_0603_1608Metric
U1: 74HC14; TSSOP-14_4.4x5mm_P0.65mm

Connections:
+3.3V: C1.1, J1.1, R1.1, R2.1, R3.1, R4.1, U1.14 (VCC)
/A_OUT: J1.2, U1.12
/B_OUT: J1.3, U1.2
GND: C1.2, J1.4, PH1.2, PH1.3, PH2.2, PH2.3, U1.3, U1.5, U1.7 (GND), U1.9, U1.11
unnamed: PH1.1, R1.2
unnamed: PH1.4, R3.2, U1.13
unnamed: PH2.1, R2.2
unnamed: PH2.4, R4.2, U1.1

Board: 2 copper layers, 31.4 x 14.5 mm, 9 parts (0 on the bottom side), 8 nets.
